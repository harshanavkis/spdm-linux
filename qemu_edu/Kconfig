## qemu_edu/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config QEMU_EDU
	tristate
	default y
        help
          "QEMU EDU device module."
```
